# Keil uVision project SDcardFATFS_play.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SDcardFATFS_play +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\main;.\STM32F10x_FWLib\inc;.\SYSTEM;.\uartprintf;.\spi_flash;.\SDIO_firmware;.\FATFS;.\FATFS\option;.\wav;.\malloc;.\I2S;.\MYIIC;.\WM8978
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
    ./main/: main.c stm32f10x_it.c system_stm32f10x.c
  group system
    ./SYSTEM/: sysclock.c
  group core
    ./CORE/: core_cm3.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uartprintf
    ./uartprintf/: uartprintf.c
  group spiflash
    ./spi_flash/: spi_flash.c norflash.c
  group SDIO_firmware
    ./SDIO_firmware/: stm32_eval_sdio_sd.c stm32_eval.c stm3210e_eval.c sdcode.c
  group FATFS
    ./FATFS/: ff.c diskio.c
    ./FATFS/option/: cc936.c
  group wav
    ./wav/: wavfmt.c
  group IIC
    ./MYIIC/: myiic.c
  group IIS
    ./I2S/: i2s.c
  group WM8978
    ./WM8978/: wm8978.c
